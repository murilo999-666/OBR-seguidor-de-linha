/*
 * ════════════════════════════════════════════════════════════════
 *  SEGUIDOR DE LINHA (PID) + PONTO VERDE — ESP32 / OBR Resgate
 * ════════════════════════════════════════════════════════════════
 *
 *  Baseado no seu "seguidor_de_linha_PID" (QTRSensors + L298N).
 *  Adicionado: detecção e tratamento dos MARCADORES VERDES das
 *  interseções, usando DOIS sensores de cor TCS34725 (esq. e dir.).
 *
 *  >>> MODO ATUAL: o robô anda RETO e testa o ponto verde (SEM
 *      seguidor de linha). Para ligar o PID depois, mude os flags
 *      MODO_SEGUIDOR_LINHA e USAR_IR na seção "MODO DE OPERAÇÃO". <<<
 *
 *  ───────────────────────────────────────────────────────────────
 *  LÓGICA DO PONTO VERDE  (exatamente o fluxo que você descreveu)
 *  ───────────────────────────────────────────────────────────────
 *  A cada ciclo: segue a linha por PID e lê os dois sensores de cor.
 *
 *   • Verde nos DOIS lados ......................... gira 180° (beco sem saída)
 *   • Verde só num lado  E  IR com 1 preto (linha normal) .. gira 90° p/ esse lado
 *   • Verde + IR com VÁRIOS pretos (cruzamento) ... segue RETO
 *       (= interseção SEM marcação: ignora o verde e vai reto)
 *   • Sem verde .................................... só segue a linha (PID)
 *
 *  ───────────────────────────────────────────────────────────────
 *  ⚠ MONTAGEM DOS SENSORES DE COR (CRÍTICO p/ a lógica funcionar)
 *  ───────────────────────────────────────────────────────────────
 *  Os 2 TCS34725 devem ficar UM POUCO À FRENTE do array de IR,
 *  um à esquerda e outro à direita da linha. Assim o robô "vê" o
 *  verde ANTES de o array de IR chegar no cruzamento — é isso que
 *  diferencia "verde antes do cruzamento" (vira) de "verde junto
 *  do cruzamento" (reto). Se inverter o lado, troque COR_ESQ_*
 *  com COR_DIR_* (ou V_ESQ/V_DIR na decisão).
 *
 *  ───────────────────────────────────────────────────────────────
 *  ⚠ CORREÇÃO DE PINOS (o exemplo de cor original NÃO funcionava)
 *  ───────────────────────────────────────────────────────────────
 *  O seu sensor_de_cor.ino usava SDA/SCL = 6/7 e 13/12:
 *    - GPIO 6 e 7 NÃO existem como I/O no ESP32 (vão pra flash
 *      interna, GPIO6–11). Travaria a placa.
 *    - GPIO 12 e 13 já são seus sensores IR (direita e extrema-dir).
 *  Como os 2 TCS34725 têm o MESMO endereço I2C (0x29), eles não
 *  podem dividir um único barramento. A solução (que a sua lib
 *  SoftI2C já permite) é usar 2 barramentos por software, em
 *  pinos LIVRES de verdade:
 *    - Cor ESQUERDA : SDA=16  SCL=17   (os "I2C" do Savio)
 *    - Cor DIREITA  : SDA=4   SCL=5    (livres)
 *
 *  ───────────────────────────────────────────────────────────────
 *  GIRO 90°/180°
 *  ───────────────────────────────────────────────────────────────
 *  Aqui o giro é por TEMPO (calibrável), porque os 4 pinos livres
 *  bons foram para os 2 sensores de cor — não sobrou barramento I2C
 *  para o giroscópio sem um multiplexador (TCA9548A). Há uma função
 *  reencontrarLinha() que faz ajuste fino até reachar a linha, o que
 *  compensa boa parte do erro de tempo. Veja "UPGRADE: GIROSCÓPIO"
 *  no fim do arquivo para trocar por MPU6050 quando quiser.
 * ════════════════════════════════════════════════════════════════
 */

// #include <Wire.h>                      // só se for usar giroscópio (ver fim)
#include <L298N.h>
#include <QTRSensors.h>
#include "Adafruit_TCS34725softi2c.h"     // mesma lib do seu exemplo

// ─────────────────────────────────────────────────────────────
//  PINOS
// ─────────────────────────────────────────────────────────────
// Ponte H
#define AIN1 21
#define AIN2 22
#define PWMA 23
#define BIN1 25
#define BIN2 33
#define PWMB 32

// Buzzer (Savio: D15)
#define PIN_BUZZER 15

// Sensores de cor (SoftI2C) — ver nota de pinos no cabeçalho
#define COR_ESQ_SDA 16
#define COR_ESQ_SCL 17
#define COR_DIR_SDA 4
#define COR_DIR_SCL 5

// IR / QTR: pinos {26, 27, 14, 12, 13} = EE, E, C, D, ED

// ─────────────────────────────────────────────────────────────
//  OBJETOS
// ─────────────────────────────────────────────────────────────
L298N motorEsq(PWMA, AIN1, AIN2);   // motor ESQUERDO
L298N motorDir(PWMB, BIN1, BIN2);   // motor DIREITO

QTRSensors qtr;
const uint8_t SensorCount = 5;
uint16_t sensorValues[SensorCount];

Adafruit_TCS34725softi2c corEsq =
  Adafruit_TCS34725softi2c(TCS34725_INTEGRATIONTIME_24MS, TCS34725_GAIN_4X, COR_ESQ_SDA, COR_ESQ_SCL);
Adafruit_TCS34725softi2c corDir =
  Adafruit_TCS34725softi2c(TCS34725_INTEGRATIONTIME_24MS, TCS34725_GAIN_4X, COR_DIR_SDA, COR_DIR_SCL);

// ─────────────────────────────────────────────────────────────
//  PID  (mantidos os seus valores)
// ─────────────────────────────────────────────────────────────
float Kp = 35;
float Ki = 0;
float Kd = 0;
uint8_t multiP = 1, multiI = 1, multiD = 1;
float Pvalue, Ivalue, Dvalue;
int P, I, D, previousError, error;
int lsp, rsp;
int lfspeed = 120;                  // velocidade base do seguidor

// ─────────────────────────────────────────────────────────────
//  PARÂMETROS — CALIBRAR NO ROBÔ REAL
// ─────────────────────────────────────────────────────────────
// IR (readLineBlack: 0 = branco, 1000 = preto)
const uint16_t LIMIAR_PRETO = 600;  // acima disso o sensor está no PRETO
const int N_PRETOS_CRUZAMENTO = 4;  // nº de sensores no preto p/ ser "cruzamento"

// Giro por tempo (ms) — calibre girando o robô no piso
const int VEL_GIRO     = 130;       // velocidade da rotação principal
const int VEL_GIRO_FINO = 110;      // velocidade do ajuste fino
const int VEL_BUSCA    = 120;       // velocidade ao procurar a linha perdida
const int T_GIRO_90    = 360;       // tempo p/ ~90°   ← CALIBRAR
const int T_GIRO_180   = 720;       // tempo p/ ~180°  ← CALIBRAR
const int T_AVANCO_EIXO = 220;      // avança p/ centralizar o eixo no cruzamento

// Cor — CALIBRAR usando o Monitor Serial (DEBUG = true)
const int   COR_CLEAR_MIN   = 120;  // 'c' abaixo disso = escuro demais (preto/sombra) -> não é verde
const float COR_FATOR_VERDE = 1.20; // o canal G precisa ser 20% maior que R e B
const float COR_PROP_VERDE  = 0.38; // proporção mínima  G / (R+G+B)

const unsigned long COOLDOWN_VERDE = 700;  // ms ignorando verde após tratar um marcador

// ─────────────────────────────────────────────────────────────
//  MODO DE OPERAÇÃO
//    AGORA  : robô anda RETO e testa o PONTO VERDE (sem seguidor).
//    FUTURO : ligue o PID trocando os flags abaixo.
// ─────────────────────────────────────────────────────────────
// false = anda reto  |  true = segue a linha por PID (exige USAR_IR = true)
const bool MODO_SEGUIDOR_LINHA = false;
// false = ignora IR (só motores + 2 sensores de cor)
// true  = lê o QTR p/ detectar cruzamento (interseção sem marcação -> reto)
const bool USAR_IR = false;

// Liga/desliga prints no Monitor Serial (115200 bps)
const bool DEBUG = true;

// ─────────────────────────────────────────────────────────────
//  ESTADO
// ─────────────────────────────────────────────────────────────
uint16_t rE, gE, bE, cE;            // última leitura de cor (esq)
uint16_t rD, gD, bD, cD;            // última leitura de cor (dir)
unsigned long ignorarVerdeAte = 0;

#define V_NENHUM 0
#define V_ESQ    1
#define V_DIR    2
#define V_AMBOS  3

// ═════════════════════════════════════════════════════════════
//  SETUP
// ═════════════════════════════════════════════════════════════
void setup() {
  Serial.begin(115200);

  // --- QTR (só se USAR_IR) ---
  if (USAR_IR) {
    qtr.setTypeAnalog();
    qtr.setSensorPins((const uint8_t[]){26, 27, 14, 12, 13}, SensorCount);
  }

  pinMode(PIN_BUZZER, OUTPUT);
  digitalWrite(PIN_BUZZER, LOW);

  // --- Sensores de cor ---
  if (!corEsq.begin()) Serial.println(F("TCS34725 ESQUERDO nao encontrado (SDA16/SCL17)"));
  if (!corDir.begin()) Serial.println(F("TCS34725 DIREITO  nao encontrado (SDA4/SCL5)"));
  // Liga os LEDs dos sensores e DEIXA ligados (leitura estável, sem delay por ciclo)
  corEsq.setInterrupt(false);
  corDir.setInterrupt(false);

  // --- Calibração do QTR (~10 s) — só se USAR_IR. Passe sobre linha e fundo. ---
  if (USAR_IR) {
    beepCurto();
    for (uint16_t i = 0; i < 400; i++) qtr.calibrate();
    beepCurto(); delay(80); beepCurto();   // 2 bipes = fim da calibração
  } else {
    beepCurto(); delay(80); beepCurto();   // pronto (modo reto, sem calibrar IR)
  }

  delay(500);
}

// ═════════════════════════════════════════════════════════════
//  LOOP
// ═════════════════════════════════════════════════════════════
void loop() {
  // 1) Lê a linha (só se USAR_IR)
  if (USAR_IR) {
    uint16_t position = qtr.readLineBlack(sensorValues);
    error = 2000 - �nsition;
  }

  // 2) Lê o�!�nis sensores de cor (preenche rE.. e rD..)
  uint8_t verdeRaw = lerVerde();
  uint8_t verde = (millis() < ignorarVerdeAte) ? V_NENHUM : verdeRaw;

  bool cruz = USAR_IR ? cruzamentoCompleto() : false;

  // 3) Decisão (ordem importa)
  if (verde == V_AMBOS) {                         // beco sem saída
    girar(180);
    ignorarVerdeAte = millis() + COOLDOWN_VERDE + 200;

  } else if (verde == V_ESQ && !cruz) {           // marcador à esquerda
    girar(-90);
    ignorarVerdeAte = millis() + COOLDOWN_VERDE;

  } else if (verde == V_DIR && !cruz) {           // marcador à direita
    girar(+90);
    ignorarVerdeAte = millis() + COOLDOWN_VERDE;

  } else if (verde != V_NENHUM && cruz) {         // interseção SEM marcação -> reto
    beepCurto();
    avancarReto(lfspeed, T_AVANCO_EIXO + 120);    // atravessa o cruzamento reto
    ignorarVerdeAte = millis() + COOLDOWN_VERDE;

  } else {                                        // entre marcadores
    if (MODO_SEGUIDOR_LINHA && USAR_IR) seguirLinhaPID(error);  // (futuro) segue a linha
    else                                andarReto();            // (agora) só anda reto
  }

  if (DEBUG) debug(verdeRaw, cruz);
}

// ═════════════════════════════════════════════════════════════
//  SEGUIDOR DE LINHA (PID)
// ═════════════════════════════════════════════════════════════
void seguirLinhaPID(int err) {
  // Linha perdida (nenhum sensor no preto): procura girando p/ o lado do último erro
  if (linhaPerdida()) {
    if (previousError > 0) motor_drive(-VEL_BUSCA, VEL_BUSCA);  // linha estava à esquerda
    else                   motor_drive(VEL_BUSCA, -VEL_BUSCA);  // senão, à direita
    return;
  }

  P = err;
  I = I + err;
  D = err - previousError;

  Pvalue = (Kp / pow(10, multiP)) * P;
  Ivalue = (Ki / pow(10, multiI)) * I;
  Dvalue = (Kd / pow(10, multiD)) * D;

  float PIDvalue = Pvalue + Ivalue + Dvalue;
  previousError = err;

  lsp = lfspeed - PIDvalue;
  rsp = lfspeed + PIDvalue;

  lsp = constrain(lsp, -150, 150);
  rsp = constrain(rsp, -150, 150);

  motor_drive(lsp, rsp);
}

// ═════════════════════════════════════════════════════════════
//  MOTORES
//    motor_drive(esq, dir): valor > 0 = frente, < 0 = ré
//    Confere com sua recuperação original:
//      motor_drive(-v,+v) = gira ESQUERDA ; motor_drive(+v,-v) = DIREITA
// ═════════════════════════════════════════════════════════════
void motor_drive(int esq, int dir) {
  if (dir >= 0) { motorDir.setSpeed(dir);  motorDir.forward(); }
  else          { motorDir.setSpeed(-dir); motorDir.backward(); }

  if (esq >= 0) { motorEsq.setSpeed(esq);  motorEsq.forward(); }
  else          { motorEsq.setSpeed(-esq); motorEsq.backward(); }
}

void parar() {
  motorEsq.stop();
  motorDir.stop();
}

void avancarReto(int vel, int t) {
  motor_drive(vel, vel);
  delay(t);
}

// Anda reto continuamente (modo de teste, sem seguidor de linha)
void andarReto() {
  motor_drive(lfspeed, lfspeed);
}

// ═════════════════════════════════════════════════════════════
//  GIRO
//    graus < 0  -> esquerda ;  graus >= 0 -> direita
//    |graus| >= 180 usa T_GIRO_180, senão T_GIRO_90
// ═════════════════════════════════════════════════════════════
void girar(int graus) {
  beepCurto();
  parar(); delay(80);

  // Centraliza o eixo de rotação sobre o cruzamento
  avancarReto(lfspeed, T_AVANCO_EIXO);
  parar(); delay(60);

  int dir = (graus < 0) ? -1 : +1;                 // -1 esq, +1 dir
  int t   = (abs(graus) >= 180) ? T_GIRO_180 : T_GIRO_90;

  if (dir < 0) motor_drive(-VEL_GIRO, VEL_GIRO);   // esquerda
  else         motor_drive(VEL_GIRO, -VEL_GIRO);   // direita
  delay(t);
  parar(); delay(60);

  reencontrarLinha(dir);   // ajuste fino: completa o giro até achar a linha
}

// Continua girando devagar (mesmo sentido) até o sensor CENTRAL achar a linha
void reencontrarLinha(int dir) {
  unsigned long t0 = millis();
  while (millis() - t0 < 600) {                    // timeout de segurança
    qtr.readLineBlack(sensorValues);
    if (sensorValues[2] > LIMIAR_PRETO) break;     // centro encontrou a linha
    if (dir < 0) motor_drive(-VEL_GIRO_FINO, VEL_GIRO_FINO);
    else         motor_drive(VEL_GIRO_FINO, -VEL_GIRO_FINO);
  }
  parar(); delay(40);
}

// ═════════════════════════════════════════════════════════════
//  IR / QTR — auxiliares
// ═════════════════════════════════════════════════════════════
int contarPreto() {
  int n = 0;
  for (uint8_t i = 0; i < SensorCount; i++)
    if (sensorValues[i] > LIMIAR_PRETO) n++;
  return n;
}

bool cruzamentoCompleto() { return contarPreto() >= N_PRETOS_CRUZAMENTO; }
bool linhaPerdida()       { return contarPreto() == 0; }

// ═════════════════════════════════════════════════════════════
//  COR
//    Detecção de VERDE robusta por proporção de canais (não depende
//    de acertar branco/preto, que era o problema do exemplo).
// ═════════════════════════════════════════════════════════════
bool ehVerde(uint16_t r, uint16_t g, uint16_t b, uint16_t c) {
  if (c < COR_CLEAR_MIN) return false;             // escuro demais = preto/sombra
  long soma = (long)r + g + b;
  if (soma <= 0) return false;
  float prop = (float)g / soma;                    // quanto do total é verde
  // Verde = G claramente maior que R e B  E  proporção alta
  return (g > r * COR_FATOR_VERDE) &&
         (g > b * COR_FATOR_VERDE) &&
         (prop > COR_PROP_VERDE);
}

// Retorna V_NENHUM / V_ESQ / V_DIR / V_AMBOS
uint8_t lerVerde() {
  // OBS: se a SUA versão da lib usar 'int' (como no seu exemplo),
  //      troque uint16_t por int aqui e nas globais rE..cD.
  corEsq.getRawData(&rE, &gE, &bE, &cE);
  corDir.getRawData(&rD, &gD, &bD, &cD);

  uint8_t res = V_NENHUM;
  if (ehVerde(rE, gE, bE, cE)) res |= V_ESQ;
  if (ehVerde(rD, gD, bD, cD)) res |= V_DIR;
  return res;
}

// ═════════════════════════════════════════════════════════════
//  BUZZER (ativo). Para buzzer passivo, use tone()/noTone().
// ═════════════════════════════════════════════════════════════
void beepCurto() {
  digitalWrite(PIN_BUZZER, HIGH);
  delay(60);
  digitalWrite(PIN_BUZZER, LOW);
}

// ═════════════════════════════════════════════════════════════
//  DEBUG (Monitor Serial @115200) — use p/ calibrar IR e cor
//    IR: #=preto  .=branco | depois os valores RGBC de cada sensor
// ═════════════════════════════════════════════════════════════
void debug(uint8_t verde, bool cruz) {
  static unsigned long t = 0;
  if (millis() - t < 200) return;
  t = millis();

  if (USAR_IR) {
    Serial.print(F("IR:"));
    for (uint8_t i = 0; i < SensorCount; i++)
      Serial.print(sensorValues[i] > LIMIAR_PRETO ? '#' : '.');
    Serial.print(F("  cruz=")); Serial.print(cruz);
  } else {
    Serial.print(F("IR:off"));
  }

  Serial.print(F("  Verde="));
  Serial.print(verde == V_AMBOS ? "AMBOS" : verde == V_ESQ ? "ESQ" :
               verde == V_DIR   ? "DIR"   : "-");

  Serial.print(F("  | E rgbc=")); Serial.print(rE); Serial.print(',');
  Serial.print(gE); Serial.print(','); Serial.print(bE); Serial.print(','); Serial.print(cE);
  Serial.print(F("  D rgbc=")); Serial.print(rD); Serial.print(',');
  Serial.print(gD); Serial.print(','); Serial.print(bD); Serial.print(','); Serial.print(cD);
  Serial.println();
}

/*
 * ════════════════════════════════════════════════════════════
 *  COMO CALIBRAR  (faça nesta ordem)
 * ════════════════════════════════════════════════════════════
 *  1) IR / LIMIAR_PRETO e N_PRETOS_CRUZAMENTO
 *     Com DEBUG = true, abra o Monitor Serial. Coloque o robô na
 *     linha e veja o padrão "IR: . # . . .". Sobre um cruzamento (+)
 *     deve aparecer "# # # # #". Ajuste LIMIAR_PRETO até o '#'
 *     aparecer só onde há preto. N_PRETOS_CRUZAMENTO = 4 já costuma
 *     servir (use 3 se seu array for mais estreito).
 *
 *  2) COR / verde
 *     Veja os valores "E rgbc=" e "D rgbc=" passando cada sensor
 *     sobre: branco, preto e VERDE do marcador.
 *       - No verde, G deve ser nitidamente maior que R e B.
 *       - Ajuste COR_FATOR_VERDE (↑ fica mais exigente) e
 *         COR_PROP_VERDE até "Verde=ESQ/DIR" só acender no verde.
 *       - Ajuste COR_CLEAR_MIN logo acima do 'c' do preto, para
 *         o preto nunca ser lido como verde.
 *
 *  3) GIRO / T_GIRO_90 e T_GIRO_180
 *     Faça o robô girar e meça o ângulo. Aumente/diminua os tempos.
 *     Bateria mais fraca gira menos — recalibre se trocar a carga.
 *     reencontrarLinha() corrige pequenos erros automaticamente.
 *
 *  4) Se o seguidor ficar "lento/tremido": a leitura dos 2 sensores
 *     de cor a cada ciclo custa tempo. Opções:
 *       - reduzir a integração p/ TCS34725_INTEGRATIONTIME_2_4MS
 *         (e subir o ganho p/ _16X);  ou
 *       - ler a cor só a cada N ciclos.
 *
 * ════════════════════════════════════════════════════════════
 *  UPGRADE: GIROSCÓPIO (giro 90°/180° preciso)
 * ════════════════════════════════════════════════════════════
 *  O giro por tempo varia com a bateria. Para usar um MPU6050:
 *
 *  PROBLEMA DE PINOS: o MPU6050 é I2C (endereço 0x68). Os pinos
 *  bons (16,17,4,5) já foram para os 2 sensores de cor. Para somar
 *  o giroscópio sem conflito, a forma limpa é um multiplexador
 *  I2C TCA9548A: tudo no Wire (SDA=16/SCL=17), e o mux dá um canal
 *  para o giroscópio e um para cada TCS34725.
 *
 *  Depois, troque o miolo de girar() por algo assim:
 *
 *    void girar(int graus) {
 *      parar(); delay(80);
 *      avancarReto(lfspeed, T_AVANCO_EIXO); parar(); delay(60);
 *      float alvo = abs(graus);
 *      float acumulado = 0;
 *      unsigned long tAnt = millis();
 *      int dir = (graus < 0) ? -1 : +1;
 *      while (acumulado < alvo) {
 *        if (dir < 0) motor_drive(-VEL_GIRO, VEL_GIRO);
 *        else         motor_drive(VEL_GIRO, -VEL_GIRO);
 *        float gz = lerGiroZ_graus_por_seg();      // do MPU6050
 *        unsigned long agora = millis();
 *        acumulado += fabs(gz) * (agora - tAnt) / 1000.0;
 *        tAnt = agora;
 *      }
 *      parar(); delay(60);
 *      reencontrarLinha(dir);
 *    }
 * ════════════════════════════════════════════════════════════
 */
